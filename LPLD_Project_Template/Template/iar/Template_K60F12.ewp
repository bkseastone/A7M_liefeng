# IAR project Template_K60F12.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: LPLD_K60; USE_K60F15
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class; ..\app\_cal; ..\app\_config; ..\app\_dev
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_K60F12.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: 512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  ICCARM.CCDefines: LPLD_K60; USE_K60F12
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60FN1M0_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  ICCARM.CCDefines: LPLD_K60; USE_K60F12
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60FN1M0_BOOT.icf
  group app
    ../app/: k60_card.h Template.c
  group app/cal
    ../app/_cal/: ov_cal.c ov_cal.h rectify.c rectify.h servoPID.c servoPID.h
  group app/conf
    ../app/_config/: GPIOConfig.c GPIOConfig.h interrupt.c interrupt.h log.h time.c time.h UART.c UART.h voltage.c voltage.h
  group app/dev
    ../app/_dev/: encoder.c encoder.h motor.c motor.h OV7725_eagle.c OV7725_eagle.h servomotor.c servomotor.h
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: MK60F15.h startup_K60F12.s system_MK60.c system_MK60F15.h
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    ../../../lib/LPLD/DEV/: DEV_SCCB.c DEV_SCCB.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_DMA.c HW_DMA.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_UART.c HW_UART.h
